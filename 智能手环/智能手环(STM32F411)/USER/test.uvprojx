# Keil uVision project test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F411xE,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\sys;..\USER;..\STM32F4xx_StdPeriph_Driver\inc;..\HARDWARE\inc;..\SYSTEM\delay;..\SYSTEM\nvic;..\SYSTEM\time;..\SYSTEM\usart;..\FUNCTIONS
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group USER
    ../SYSTEM/sys/: system_stm32f4xx.c
    ./: startup_stm32f40_41xxx.s test.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/nvic/: nvic.c
    ../SYSTEM/time/: time.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/src/: led.c key.c motor.c pwm.c OLED.c matrix.c adc.c iic.c sht20.c hp6.c mpu6050.c rtc.c
  group STM32F4xx_StdPeriph_Driver
    ../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group FUNCTIONS
    ../FUNCTIONS/: function.c interface.c MeterStepAlgorithm.c
